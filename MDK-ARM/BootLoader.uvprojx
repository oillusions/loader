# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BootLoader
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: .;..\Core\Inc;..\Drivers\STM32G0xx_HAL_Driver\Inc;..\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32G0xx\Include;..\Drivers\CMSIS\Include;.cmsis\include;RTE\_loader;..\OLED;..\off-Chip\W25Qxx;..\off-Chip
  asm define: USE_HAL_DRIVER,STM32G0B1xx
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c dma.c spi.c usart.c usb_drd_fs.c stm32g0xx_it.c stm32g0xx_hal_msp.c main.cpp program.cpp
  group Application/User/Core/off-Chip
    ../off-Chip/W25Qxx/: W25Qxx.cpp W25QxxStorageDevice.cpp
    ../off-Chip/: IStorageDevice.h
  group Application/User/Core/Loader
    ../Loader/: loader.cpp loader.s
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
